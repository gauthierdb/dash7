<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BT</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bit_dly</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>bit_dly</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channelNumber</value></param>
<param><key>value</key><value>140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deltaF</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussian_tx</value></param>
<param><key>value</key><value>firdes.gaussian(1,sps,BT, ntaps)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[85, 85, 85, 85]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_match_gauss</value></param>
<param><key>value</key><value>firdes.gaussian(1,sps,BT, ntaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_shape</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(ntaps, samp_rate_t, symbol_rate, alpha, ntaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_r</value></param>
<param><key>value</key><value>768e4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_t</value></param>
<param><key>value</key><value>480e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>9.6e3</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate_t/(2*np.pi*deltaF/8.0)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-((channelNumber - 139)*0.025)*1000000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_r</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/dev/pts/1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/gauthier/AfterFrameSync</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/gauthier/Downloads/Rx_data_sps50 _synchWord(0B67)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_0</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.001</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.0001</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate_t</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>comsys_crc_tagged_stream</key>
<param><key>id</key><value>comsys_crc_tagged_stream_0_0</value></param>
<param><key>check</key><value>True</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>comsys_pn9_whitening</key>
<param><key>id</key><value>comsys_pn9_whitening_1</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbols</key><value>preamble</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold</key><value>0.9</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Custom Frame synchronizer:

This block will take in a stream of floats, it will search for the syncword until its found.
In the next step the block will read in the length that is in the header after the sync word.
After that the payload equal to the length in the header will be outputted.

Jaimie Vranckx &amp; Mohammad Ali Amir &amp; Maximiliaan Walravens
"""

import numpy as np
from gnuradio import gr
import pmt

class blk(gr.basic_block):  # use of basic block so that output and input dont have to be equal
    def __init__(self, sync_word=59088, whitening=True):  # only default arguments here
        gr.basic_block.__init__(
            self,
            name='Frame synchroniser',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.sync_word = np.uint16(sync_word) # sync word of 16 bits
        self.data_buffer = np.uint16(0) #buffer for data read inside the sync state
        self.header_buffer = np.uint8(0) #buffer for data read inside the header state
        self.header_counter = 0 #count for current position in header
        self.packet_counter = 0 #count for current position in packet
        self.state = 0 # current state
	self.whitening=whitening
	self.clear_header=np.uint8(0)

    def general_work(self, input_items, output_items):

	#print(len(input_items))


	# read in the buffers
        input0 = input_items[0]
        output0 = output_items[0]

	#initialize variables
        count = 0
	produced = 0

	#loop over inputs
 	while count&lt;len(output0):
            if self.state == 0: #State 1: search for syncword
                while count &lt; len(output0):
                    self.data_buffer = np.uint16(((self.data_buffer &lt;&lt; 1) | gr.branchless_binary_slicer(np.float64(input0[count])) &amp; 0x1)) 
			#shift bit into data buffer
                    count+=1

                    #print("{0:b}".format(self.data_buffer))
                    if (self.data_buffer) ^ self.sync_word == 0 : # if syncword found

 			#reset variables
			self.header_buffer = np.uint8(0)
			self.header_counter = 0

			# next state
                        self.state = 1
                        break

            elif self.state == 1: #State 2: get header
                while count &lt; len(output0):
                    self.header_buffer = np.uint8(((self.header_buffer &lt;&lt; 1) | gr.branchless_binary_slicer(np.float64(input0[count])) &amp; 0x1))
		    output0[produced] = input0[count]
                    produced += 1
		    #print("{0:b}".format(np.uint8(self.header_buffer)))
                    count+=1
                    self.header_counter += 1

                    if self.header_counter == 8: # if full header found
			if(self.whitening):
				self.clear_header=self.header_buffer ^ np.uint8(255)
			else:
				self.clear_header=self.header_buffer	
		    	print("FOUND IT")
			#print("{0:b}".format(self.header_buffer))
			#reset variables
			self.packet_counter=0

			# next state
                        self.state = 2
                        break

            elif self.state == 2: #State 2: read in payload
                if self.packet_counter == 0 :# if start of payload add tag for next blocks to know length
                    print(self.nitems_written(0) + produced-8)
                    print(pmt.intern("packet_len"))                    
		    print(pmt.from_long(long(self.clear_header)+1))
                    self.add_item_tag(0,  # Port number
                                      self.nitems_written(0) + produced-8,  # Offset
                                      pmt.intern("packet_len"),  # Key
                                      pmt.from_long(long(self.clear_header)+1)  # Value
		    			)
		    print(long(self.clear_header))
                while count &lt; len(output0):
                    if self.packet_counter &lt; (self.clear_header)*8:	# read in buffer until length is reached
                        output0[produced] = input0[count]
			#if(count==len(output0)
                        produced += 1
                        count += 1
                        self.packet_counter += 1
                    else: # if payload is read in entirely
			#reset variables
			self.data_buffer = 0
			print("Passed frame sync")
			# next state
                        self.state = 0
                        break

    	self.consume_each(count) # set number of consumed inputs in buffer
    	return produced	# set nu;ber of produced outputs in output buffer

</value></param>
<param><key>sync_word</key><value>29848</value></param>
<param><key>whitening</key><value>True</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>sps</value></param>
<param><key>samp_delay</key><value>1</value></param>
<param><key>taps</key><value>rrc_match_gauss</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>(deltaF+symbol_rate)/3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_t</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>bw</key><value>5e5</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_1</value></param>
<param><key>bw</key><value>samp_rate_t</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_1_0</value></param>
<param><key>bw</key><value>samp_rate_t</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_magphase_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_1</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_1</source_block_id><sink_block_id>qtgui_sink_x_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_2</source_block_id><sink_block_id>blocks_magphase_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_magphase_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>comsys_pn9_whitening_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_crc_tagged_stream_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_pn9_whitening_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_pn9_whitening_1</source_block_id><sink_block_id>comsys_crc_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
