<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>message</value></param>
<param><key>value</key><value>list(ord(i) for i in '123456789')</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/dev/pts/0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>len(message)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>message</value></param>
</block>
<block>
<key>comsys_crc_tagged_stream</key>
<param><key>id</key><value>comsys_crc_tagged_stream_0</value></param>
<param><key>check</key><value>False</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>comsys_crc_tagged_stream</key>
<param><key>id</key><value>comsys_crc_tagged_stream_0_0</value></param>
<param><key>check</key><value>True</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>comsys_pn9_whitening</key>
<param><key>id</key><value>comsys_pn9_whitening_0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>comsys_pn9_whitening</key>
<param><key>id</key><value>comsys_pn9_whitening_0_0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>comsys_crc_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_crc_tagged_stream_0</source_block_id><sink_block_id>comsys_pn9_whitening_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_crc_tagged_stream_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_pn9_whitening_0</source_block_id><sink_block_id>comsys_crc_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_pn9_whitening_0_0</source_block_id><sink_block_id>comsys_pn9_whitening_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
