<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>messageconstructor</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>messageconstructor</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_0_0</value></param>
<param><key>lengths</key><value>len(preamble),1,1,len(message)+1+2</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_1</value></param>
<param><key>lengths</key><value>1, len(message)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>len(message)+1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>list(ord(i) for i in message)</value></param>
</block>
<block>
<key>comsys_crc_tagged_stream</key>
<param><key>id</key><value>comsys_crc_tagged_stream_0_1</value></param>
<param><key>check</key><value>False</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>comsys_pn9_whitening</key>
<param><key>id</key><value>comsys_pn9_whitening_0_0_0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>message</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>preamble_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>preamble</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>sync_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>[230]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>sync_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>[len(message)+2]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>sync_1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>[208]</value></param>
</block>
<connection><source_block_id>blocks_stream_mux_0_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>comsys_crc_tagged_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>comsys_crc_tagged_stream_0_1</source_block_id><sink_block_id>comsys_pn9_whitening_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>comsys_pn9_whitening_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>preamble_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sync_1_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_1_1</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
